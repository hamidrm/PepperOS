# IAR project blink_1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030F4 ST STM32F030F4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: TARGET_DEVICE=DEV_STM32F030x4
  ICCARM.CCIncludePath2: ..\..\..\..\core\include; ..\..\..\..\lib\console\; ..\..\..\..\lib\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: TARGET_DEVICE=DEV_STM32F030x4
  AARM.AUserIncludes: ..\..\..\..\core\include
  OBJCOPY.OOCOutputFile: blink_1.srec
  ILINK.IlinkOutputFile: blink_1.out
  ILINK.IlinkIcfFile: ..\..\..\..\hal\STM32F030x4\stm32f030x4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: c.out
  group core
    ../../../../core/: pepper_os.c pos_console.c pos_delay.c pos_ipc.c pos_memory.c pos_mutex.c pos_scheduler.c pos_semaphore.c pos_timer.c
  group core/arch/cm0
    ../../../../core/arch/cm0/: pos_cm0.c pos_svc.s pos_switch.s
    ../../../../core/arch/cm0/inc/: pos_cm0.h
  group core/include
    ../../../../core/include/: pepper_os.h pos_config.h pos_console.h pos_delay.h pos_devices.h pos_ipc.h pos_memory.h pos_mutex.h pos_scheduler.h pos_semaphore.h pos_timer.h pos_types.h pos_utility.h
  group hal/STM32F030x4
    ../../../../hal/STM32F030x4/src/: startup_stm32f030x4.s stm32f030x4_hal_wrapper.c stm32f030x4_init.c stm32f030x4_system.c
  group hal/STM32F030x4/drivers
    ../../../../hal/STM32F030x4/drivers/std/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group lib
    ../../../../lib/: queue.c
  group lib/include
    ../../../../lib/include/: queue.h
  group user applications
    ../src/: task1.c task1.h task2.c task2.h user_init.c

# IAR project Backup of PepperOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x4 ST STM32F030x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F030x6; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: Drivers\CMSIS\Device\ST\STM32F0xx\Include; Drivers\STM32F0xx_HAL_Driver\Inc; Drivers\CMSIS\Include; Main\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NRF24BLE.srec
  ILINK.IlinkOutputFile: NRF24BLE.out
  ILINK.IlinkIcfFile: NRF24BLE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: c.out
  group Main
    Main/: main.c nrf24l01.c nrf24l01_hal.c sleep.s
    Main/Include/: main.h nrf24l01.h nrf24l01_hal.h stm32f0xx_hal_conf.h util.h
  group MCU_HAL
    Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c
  group System
    System/: startup_stm32f030x4.s system_stm32f0xx.c
